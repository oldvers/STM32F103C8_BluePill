# IAR project STM32F103C8_BluePill_Test_ICEmkII.ewp, settings and files
configuration Test (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F103xB; STM32F10X_MD; DBG_NONE
  ICCARM.CCIncludePath2: ..\..\src; ..\..\..\..\src; ..\..\..\..\src\lib\cmsis\Include; ..\..\..\..\src\lib\cmsis\Device\ST\STM32F1xx\Include; ..\..\..\..\src\lib\freertos; ..\..\..\..\src\lib\freertos\Source\include; ..\..\..\..\src\hw; ..\..\..\..\src\lib\freertos\Source\portable\IAR\ARM_CM3; ..\..\..\..\src\lib\rtt; ..\..\..\..\src\lib\rtt\config; ..\..\..\..\src\lib\fifo; ..\..\..\..\src\usb\icemkii; ..\..\..\..\src\lib\usb; ..\..\..\..\src\usb; ..\..\..\..\src\usb\icemkii
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\src\lib\freertos
  OBJCOPY.OOCOutputFile: STM32F103C8_BluePill.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\..\src\lib\cmsis\Device\ST\STM32F1xx\Source\Templates\iar\linker\stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../src/lib/cmsis/Include/: core_cm3.h
    ../../../../src/lib/cmsis/Device/ST/STM32F1xx/Source/Templates/iar/: startup_stm32f103xb.s
    ../../../../src/lib/cmsis/Device/ST/STM32F1xx/Include/: stm32f103xb.h stm32f1xx.h system_stm32f1xx.h
    ../../../../src/lib/cmsis/Device/ST/STM32F1xx/Source/Templates/iar/linker/: stm32f103xb_flash.icf
    ../../../../src/lib/cmsis/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group FIFO
    ../../../../src/lib/fifo/: fifo.c fifo.h
  group Hardware
    ../../../../src/hw/: board.h debug.c debug.h gpio.c gpio.h interrupts.c interrupts.h system.c system.h types.h uniquedevid.h
  group Main
    ../../../: main.c
    ../../src/: mocks.c test.c
  group RTOS
    ../../../../src/lib/freertos/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../src/lib/freertos/Source/include/: FreeRTOS.h
    ../../../../src/lib/freertos/: FreeRTOSConfig.h
    ../../../../src/lib/freertos/Source/portable/MemMang/: heap_2.c
    ../../../../src/lib/freertos/Source/portable/IAR/ARM_CM3/: port.c portasm.s portmacro.h
  group RTT
    ../../../../src/lib/rtt/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_printf.c
    ../../../../src/lib/rtt/config/: SEGGER_RTT_Conf.h
  group USB
    ../../../../src/usb/: usb_config.h usb_descriptor.c usb_descriptor.h
  group USB/Core
    ../../../../src/lib/usb/: usb_cdc_definitions.h usb_control.c usb_control.h usb_definitions.h usb_descriptor_definitions.h usb_device.c usb_device.h usb_hid_definitions.h usb_msc_definitions.h
  group USB/ICEmkII
    ../../../../src/usb/icemkii/: icemkii_message.c icemkii_message.h usb_icemkii.c usb_icemkii.h usb_icemkii_definitions.h
