# IAR project STM32F103C8_Test.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F103xB; STM32F10X_MD; SIMULATOR
  ICCARM.CCIncludePath2: ..\..\src; ..\..\src\lib\cmsis\Include; ..\..\src\lib\cmsis\Device\ST\STM32F1xx\Include; ..\..\src\lib\freertos; ..\..\src\lib\freertos\Source\include; ..\..\src\hw; ..\..\src\lib\freertos\Source\portable\IAR\ARM_CM3; ..\..\src\lib\usb; ..\..\src\lib\usb\icemkii; ..\..\src\lib\fifo; ..\..\src\lib\rtt
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\src\lib\freertos
  OBJCOPY.OOCOutputFile: STM32F103C8_Test.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\src\lib\cmsis\Device\ST\STM32F1xx\Source\Templates\iar\linker\stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../src/lib/cmsis/Include/: core_cm3.h
    ../../src/lib/cmsis/Device/ST/STM32F1xx/Source/Templates/iar/: startup_stm32f103xb.s
    ../../src/lib/cmsis/Device/ST/STM32F1xx/Include/: stm32f103xb.h stm32f1xx.h system_stm32f1xx.h
    ../../src/lib/cmsis/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Hardware
    ../../src/hw/: debug.c debug.h gpio.h interrupts.c interrupts.h system.c system.h types.h uniquedevid.h usb.c usb.h
  group JTAGICEmkII
    ../../src/lib/usb/icemkii/: icemkii_message.c icemkii_message.h
  group Main
    ../: main.c
  group RTOS
    ../../src/lib/freertos/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../src/lib/freertos/Source/include/: FreeRTOS.h
    ../../src/lib/freertos/: FreeRTOSConfig.h
    ../../src/lib/freertos/Source/portable/MemMang/: heap_2.c
    ../../src/lib/freertos/Source/portable/IAR/ARM_CM3/: port.c portasm.s portmacro.h
  group RTT
    ../../src/lib/rtt/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group USB
    ../../src/lib/usb/: usb_cfg.h usb_core.c usb_core.h usb_defs.h usb_descr.c usb_descr.h usb_device.c usb_device.h
    ../../src/lib/usb/icemkii/: usb_icemkii.c usb_icemkii.h usb_icemkii_defs.h
  group Utils
    ../../src/lib/fifo/: fifo.c fifo.h
