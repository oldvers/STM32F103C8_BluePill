<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\east_block\project\iar\STM32F103C8_BluePill_Test_EastBlock.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\exceptions\project\iar\STM32F103C8_BluePill_Test_Exceptions.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\i2c\project\iar\STM32F103C8_BluePill_Test_I2C.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\real_hw_template\project\iar\STM32F103C8_BluePill_Test_RealHwTemplate.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\simulator_template\project\iar\STM32F103C8_BluePill_Test_SimulatorTemplate.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\spi\project\iar\STM32F103C8_BluePill_Test_SPI.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\fifo\project\iar\STM32F103C8_BluePill_Test_FIFO.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\block_queue\project\iar\STM32F103C8_BluePill_Test_BlockQueue.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\east_message\project\iar\STM32F103C8_BluePill_Test_EastMessage.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\usb_library\project\iar\STM32F103C8_BluePill_Test_UsbLibrary.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\icemkii\project\iar\STM32F103C8_BluePill_Test_ICEmkII.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>All_Projects</name>
            <member>
                <project>STM32F103C8_BluePill_Test_Exceptions</project>
                <configuration>Test</configuration>
            </member>
            <member>
                <project>STM32F103C8_BluePill_Test_RealHwTemplate</project>
                <configuration>Test</configuration>
            </member>
            <member>
                <project>STM32F103C8_BluePill_Test_SimulatorTemplate</project>
                <configuration>Test</configuration>
            </member>
            <member>
                <project>STM32F103C8_BluePill_Test_I2C</project>
                <configuration>Test</configuration>
            </member>
            <member>
                <project>STM32F103C8_BluePill_Test_SPI</project>
                <configuration>Test</configuration>
            </member>
            <member>
                <project>STM32F103C8_BluePill_Test_FIFO</project>
                <configuration>Test</configuration>
            </member>
            <member>
                <project>STM32F103C8_BluePill_Test_BlockQueue</project>
                <configuration>Test</configuration>
            </member>
            <member>
                <project>STM32F103C8_BluePill_Test_EastMessage</project>
                <configuration>Test</configuration>
            </member>
            <member>
                <project>STM32F103C8_BluePill_Test_EastBlock</project>
                <configuration>Test</configuration>
            </member>
            <member>
                <project>STM32F103C8_BluePill_Test_UsbLibrary</project>
                <configuration>Test</configuration>
            </member>
            <member>
                <project>STM32F103C8_BluePill_Test_ICEmkII</project>
                <configuration>Test</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
