# IAR project STM32F103C8_BluePill_Test_EastBlock.ewp, settings and files
configuration Test (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F103xB; STM32F10X_MD; DBG_NONE
  ICCARM.CCIncludePath2: ..\..\src; ..\..\..\..\src; ..\..\..\..\src\lib\cmsis\Include; ..\..\..\..\src\lib\cmsis\Device\ST\STM32F1xx\Include; ..\..\..\..\src\lib\freertos; ..\..\..\..\src\lib\freertos\Source\include; ..\..\..\..\src\hw; ..\..\..\..\src\hw\config; ..\..\..\..\src\lib\freertos\Source\portable\IAR\ARM_CM3; ..\..\..\..\src\lib\rtt; ..\..\..\..\src\lib\rtt\config; ..\..\..\..\src\lib\block_queue; ..\..\..\..\src\lib\east
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\src\lib\freertos
  OBJCOPY.OOCOutputFile: STM32F103C8_BluePill.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\..\src\lib\cmsis\Device\ST\STM32F1xx\Source\Templates\iar\linker\stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../src/lib/cmsis/Include/: core_cm3.h
    ../../../../src/lib/cmsis/Device/ST/STM32F1xx/Source/Templates/iar/: startup_stm32f103xb.s
    ../../../../src/lib/cmsis/Device/ST/STM32F1xx/Include/: stm32f103xb.h stm32f1xx.h system_stm32f1xx.h
    ../../../../src/lib/cmsis/Device/ST/STM32F1xx/Source/Templates/iar/linker/: stm32f103xb_flash.icf
    ../../../../src/lib/cmsis/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Hardware
    ../../../../src/hw/config/: board.h
    ../../../../src/hw/: debug.c debug.h gpio.c gpio.h interrupts.c interrupts.h system.c system.h types.h uniquedevid.h
  group Main
    ../../../: main.c
    ../../src/: mocks.c test.c
  group RTOS
    ../../../../src/lib/freertos/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../src/lib/freertos/Source/include/: FreeRTOS.h
    ../../../../src/lib/freertos/: FreeRTOSConfig.h
    ../../../../src/lib/freertos/Source/portable/MemMang/: heap_2.c
    ../../../../src/lib/freertos/Source/portable/IAR/ARM_CM3/: port.c portasm.s portmacro.h
  group RTT
    ../../../../src/lib/rtt/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_printf.c
    ../../../../src/lib/rtt/config/: SEGGER_RTT_Conf.h
  group Utils
    ../../../../src/lib/block_queue/: block_queue.c block_queue.h
    ../../../../src/lib/east/: east_packet.c east_packet.h
