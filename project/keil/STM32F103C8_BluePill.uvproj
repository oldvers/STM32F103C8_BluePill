# Keil uVision project STM32F103C8_BluePill.uvproj, settings and files
target STM32F103C8 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32F103C8_BluePill +hex
  AfterMake: fromelf --bin --output=.\build\exe\STM32F103C8_BluePill.bin .\build\obj\STM32F103C8_BluePill.axf
  AfterMake: fromelf -c --output=.\build\lst\Full_Listing.txt .\build\obj\STM32F103C8_BluePill.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F103xB,STM32F10X_MD
  c misc: --c99
  c include: ..\..\src\;..\..\src\lib\cmsis\Include;..\..\src\lib\cmsis\Device\ST\STM32F1xx\Include;..\..\src\lib\freertos;..\..\src\lib\freertos\Source\include;..\..\src\lib\freertos\Source\portable\Keil\ARM_CM3;..\..\src\hw;..\..\src\lib\usb;..\..\src\lib\usb\icemkii;..\..\src\lib\fifo
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../../src/lib/cmsis/Device/ST/STM32F1xx/Source/Templates/keil/: startup_stm32f103xb.s
    ../../src/lib/cmsis/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group FreeRTOS
    ../../src/lib/freertos/: FreeRTOSConfig.h
    ../../src/lib/freertos/Source/: timers.c croutine.c event_groups.c list.c queue.c tasks.c
    ../../src/lib/freertos/Source/portable/MemMang/: heap_2.c
    ../../src/lib/freertos/Source/portable/Keil/ARM_CM3/: port.c
  group Main
    ../../src/: main.c
  group Hardware
    ../../src/hw/: types.h uniquedevid.h interrupts.h interrupts.c system.h system.c gpio.h debug.h debug.c usb.h usb.c
  group USB
    ../../src/lib/usb/: usb_cfg.h usb_defs.h usb_descr.h usb_descr.c usb_core.h usb_core.c usb_device.h usb_device.c
    ../../src/lib/usb/icemkii/: icemkii.c icemkii.h icemkii_defs.h
  group Utils
    ../../src/lib/fifo/: fifo.c fifo.h
